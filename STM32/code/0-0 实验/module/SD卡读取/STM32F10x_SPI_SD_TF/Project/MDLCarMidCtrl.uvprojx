# Keil uVision project MDLCarMidCtrl.uvprojx, settings and files
target MidController (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDLCarMidCtrl +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User;..\library\STM32F10x_StdPeriph_Driver\src;..\library\STM32F10x_StdPeriph_Driver\inc;..\library\CMSIS\CM3\CoreSupport;..\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\library\CMSIS\CM3\DeviceSupport;..\User\Diskio;..\User\FatFS;..\User\Msd;..\Public
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS_StartUP
    ../library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s
  group Library_Peripheral
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User_MEng
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group TF_Card
    ../User/Diskio/: diskio.c
    ../User/Msd/: msd.c
    ../User/FatFS/: ff.c
  group Public
    ../Public/: usart.c system.c
